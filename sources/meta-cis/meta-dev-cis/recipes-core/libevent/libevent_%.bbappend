PACKAGECONFIG_append = " openssl"
