# Keil uVision project onenet.uvprojx, settings and files
target onenet (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: onenet +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\core\;.\fwlib\inc\;.\drivers\;.\inc\
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./core/startup/arm/: startup_stm32f10x_md.s
  group Core
    ./core/: system_stm32f10x.c
  group Fwlib
    ./fwlib/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c
  group Drivers
    ./drivers/: delay.c usart.c
  group Module
    ./src/: onenet.c esp8266.c MqttKit.c hmac_sha1.c base64.c cJSON.c
  group App
    ./: demo_main.c
software components: CMSIS:CORE 5.1.1
